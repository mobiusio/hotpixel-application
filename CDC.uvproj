# Keil uVision project CDC.uvproj, settings and files
target KL25Z (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: CDC
  c flags: Optim=1
  c include: .;.\usb;..\ff9b\src
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x1c000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Support
    ./: startup_MKL25Z4.s system_MKL25Z4.c
  group USB
    ./usb/: usb_class.c usb_cdc.c usb_cdc_pstn.c usb_dci_kinetis.c usb_driver.c usb_framework.c
  group App
    ./: main.c RealTimerCounter_kinetis.c i2c.c led.c ui.c spi.c fileio.c
    ./usb/: usb_descriptor.c wdt_kinetis.c virtual_com.c
  group FatFS
    ../ff9b/src/: ff.c
    ../ff9b/port/: mmc-mkl25z.c
